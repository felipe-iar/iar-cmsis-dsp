# IAR project arm_cortexM_math.ewp, settings and files
configuration cortexM0l (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; ARM_MATH_LOOPUNROLL; DISABLEFLOAT16
  ICCARM.IExtraOptions: --silent
  ICCARM.CCIncludePath2: ../CMSIS-DSP/Include; ../CMSIS-DSP/PrivateInclude; ../CMSIS_6/CMSIS/Core/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
configuration cortexM0b (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; ARM_MATH_LOOPUNROLL; ARM_MATH_BIG_ENDIAN; DISABLEFLOAT16
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration cortexM3l (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
configuration cortexM3b (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: as above
configuration cortexM4l (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
configuration cortexM4b (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
  ICCARM.CCDefines: as above
configuration cortexM4lf (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
configuration cortexM4bf (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: as above
configuration cortexM7l (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 41
configuration cortexM7b (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
  ICCARM.CCDefines: as above
configuration cortexM7ls (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 6
configuration cortexM7bs (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: as above
configuration cortexM7lf (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 7
configuration cortexM7bf (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: as above
configuration ARMv8MBLl (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 60
configuration ARMv8MMLl (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 61
configuration ARMv8MMLlfsp (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 61
  General.FPU2: 6
configuration ARMv8MMLlfdp (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 61
  General.FPU2: 7
configuration ARMv8MMLld (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 61
configuration ARMv8MMLldfsp (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 61
  General.FPU2: 6
configuration ARMv8MMLldfdp (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 61
  General.FPU2: 7
configuration ARMv81MMLld (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 64
configuration ARMv81MMLldfdp (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 64
  General.FPU2: 7
configuration ARMv81MMLldfdph (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; ARM_MATH_LOOPUNROLL; ARM_MATH_MVE_FLOAT16
  ICCARM.CCIncludePath2: ../CMSIS_6/CMSIS/Core/Include; ../CMSIS-DSP/Include; ../CMSIS-DSP/PrivateInclude; ../../ComputeLibrary/Include
  group BasicMathFunctions
    ../CMSIS-DSP/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
  group BayesFunctions
    ../CMSIS-DSP/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
  group CommonTables
    ../CMSIS-DSP/Source/CommonTables/: CommonTables.c CommonTablesF16.c
  group ComplexMathFunctions
    ../CMSIS-DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
  group ControllerFunctions
    ../CMSIS-DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group DistanceFunctions
    ../CMSIS-DSP/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
  group FastMathFunctions
    ../CMSIS-DSP/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
  group FilteringFunctions
    ../CMSIS-DSP/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
  group InterpolationFunctions
    ../CMSIS-DSP/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
  group MatrixFunctions
    ../CMSIS-DSP/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
  group StatisticsFunctions
    ../CMSIS-DSP/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
  group SupportFunctions
    ../CMSIS-DSP/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
  group SVMFunctions
    ../CMSIS-DSP/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
  group TransformFunctions
    ../CMSIS-DSP/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group WindowFunctions
    ../CMSIS-DSP/Source/WindowFunctions/: WindowFunctions.c
