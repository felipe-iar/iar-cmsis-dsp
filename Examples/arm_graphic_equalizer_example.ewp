# IAR project arm_graphic_equalizer_example.ewp, settings and files
configuration cortexM4lf (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; SEMIHOSTING
  ICCARM.IExtraOptions: --silent
  ICCARM.CCIncludePath2: $_CMSIS_DSP_PATH_$/CMSIS_6/CMSIS/Core/Include; $_CMSIS_DSP_PATH_$/CMSIS-DSP/Include; ..\CMSIS-DSP\Examples\ARM\$PROJ_FNAME$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: arm_bayes_example.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: $_CMSIS_DSP_PATH_$/Lib/iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../CMSIS-DSP/Examples/ARM/arm_graphic_equalizer_example/: arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c math_helper.c
